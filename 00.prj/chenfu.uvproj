# Keil uVision project chenfu.uvproj, settings and files
target chenfu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CDG_MD_B_B1_200_386 +hex
  AfterMake: fromelf --bin --output @L.bin "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\05.sys_os;..\05.sys_os\src;..\06.st_driver;..\06.st_driver\00.st_bsp;..\06.st_driver\00.st_bsp\00.mdk;..\06.st_driver\00.st_bsp\01.sys;..\06.st_driver\00.st_bsp\02.driver;..\06.st_driver\00.st_bsp\02.driver\cm3;..\06.st_driver\00.st_bsp\02.driver\inc;..\06.st_driver\00.st_bsp\02.driver\src;..\01.app;..\02.cmm;..\02.cmm\00.type;..\02.cmm\01.queue;..\02.cmm\02.common;..\03.pro;..\03.pro\00.DGUSVPro;..\04.driver;..\04.driver\00.usart;..\04.driver\01.stm32f207bsp;..\04.driver\02.os_bsp;..\04.driver\03.SPIFlash;..\04.driver\04.gpio;..\04.driver\05.rtc;..\04.driver\06.adc;..\04.driver\07.timer;..\03.pro\01.temp;..\04.driver\08.eeprom;..\04.driver\09.watchdog;..\07.errLogicAnalyze;..\07.errLogicAnalyze\00.sysErr;..\07.errLogicAnalyze\01.apiErr;..\04.driver\10.backup;..\04.driver\11.can;..\02.cmm\03.fileOperate;..\03.pro\02.cjson;..\09.debug\00.list
  memory RVCT4: ROM 0x8040000 size 0x5ffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  group 01.app
    ../01.app/: app_cfg.h includes.h main.c main.h upperlayer.h upperlayer_parse.c upperlayer_reply.c sysCtrLogic.c sysCtrLogic.h lowerlayer.h lowerlayer_parse.c lowerlayer_reply.c sysParam.c sysParam.h upgradeLL.h upgradeLL_Parse.c upgradeLL_Reply.c compatibilityDefine.h binFileParam.h upgradeFlashAddrAllot.h comBoardUpgradeParam.c comBoardUpgradeParam.h lcdData_DW.c lcdData_DW.h hmi_DW_Data.c hmi_DW_Data.h hmi_DW_Data_Fun.c SMComManager.c SMComManager.h LCDData_DW_Fun.c SMComManager_Fun.c upgradeUL.h upgradeUL_Parse.c ctrGetUpgrFilePara.c ctrGetUpgrFilePara.h upgrFlashAddrAllot.c upgrEepromAddr.c upgrEepromAddr.h cabinetCtrInfo.c cabinetCtrInfo.h lcdData_Voice.c lcdData_Voice.h calcPhaseVolCur.c calcPhaseVolCur.h phaseVCLimitAnalyze.c phaseVCLimitAnalyze.h lower_Upgr_Analyze.c lower_Upgr_Analyze.h modifyEepromLogic.c modifyEepromLogic.h upgrFailReson.c upgrFailReson.h interface_SW.h interface_SW.c
  group 02.cmm
    ../02.cmm/00.type/: type.h
    ../02.cmm/01.queue/: queue.c queue.h seqQueue.c seqQueue.h fifoQueue.c fifoQueue.h
    ../02.cmm/02.common/: common.c common.h
    ../02.cmm/03.fileOperate/: fileopt.c fileopt.h
  group 03.pro
    ../03.pro/00.DGUSVPro/: DGUSVPro.c DGUSVPro.h
    ../03.pro/01.temp/: temp.c temp.h
  group 04.driver
    ../04.driver/00.usart/: usart.c usart.h usart_debug.c usart3.c usart1.c
    ../04.driver/01.stm32f207bsp/: stm32f207bsp.c stm32f207bsp.h
    ../04.driver/02.os_bsp/: os_bsp.c os_bsp.h
    ../04.driver/11.can/: can.c can.h can_1.c can_1.h canFilterDesign.c canFilterDesign.h can_2.c can_2.h
    ../04.driver/04.gpio/: gpio.c gpio.h
    ../04.driver/09.watchdog/: watchdog.c watchdog.h
    ../04.driver/03.SPIFlash/: SPIFlash.c SPIFlash.h
    ../04.driver/10.backup/: backup.c backup.h
    ../04.driver/08.eeprom/: FM24CL16.c FM24CL16.h
    ../04.driver/05.rtc/: rtc.c rtc.h
    ../04.driver/06.adc/: adc.c adc.h
    ../04.driver/07.timer/: timer.c timer.h timer5.c timer5.h
  group 05.sys_os
    ../05.sys_os/: os_cfg.h os_cpu.h ucos_ii.h
    ../05.sys_os/src/: os_core.c os_cpu_a.asm os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group 06.st_driver
    ../06.st_driver/00.st_bsp/00.mdk/: startup_stm32f2xx.s
    ../06.st_driver/00.st_bsp/01.sys/: system_stm32f2xx.c
    ../06.st_driver/00.st_bsp/02.driver/cm3/: core_cm3.c core_cm3.h
    ../06.st_driver/00.st_bsp/02.driver/inc/: misc.h stm32f2xx.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_conf.h stm32f2xx_crc.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_it.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h system_stm32f2xx.h
    ../06.st_driver/00.st_bsp/02.driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
